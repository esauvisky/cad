File: pcb holder/mini_heatplate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: updates
Routing:
- net (no net): track 2281.9 -> 2389.5 mm
